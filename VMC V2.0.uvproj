# Keil uVision project VMC V2.0.uvproj, settings and files
target VMC-V2.02 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EV_gprs_V1.0 +hex
  c flags: Optim=1
  c include: .\ssl
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Firmware\SRAM_SCT.sct
  link misc: --entry __main
  group APP
    ./APP/: MAIN.C COMMON.C LANGUAGE.C
  group API
    ./API/: qrencodeApi.c gprsApi.c alipayApi.c
  group DRIVERS
    ./Drivers/: UART2.C UART0.C UART1.C UART3.C RTC.C I2C.C LCD.C KEY.C TIMER.C BUZZER.C AT45DB161D.C GPRS_UART.c board.c gprs.c
  group uCOS-II
    ./uCOS_II/cpu/: Os_cpu_c.c
    ./uCOS_II/hook/: uCOS-II hook.lib
    ./uCOS_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_TIME.C OS_TASK.C OS_SEM.C OS_Q.C OS_MUTEX.C
  group FIRMWARE
    ./Firmware/: LPC1700PinCfg.c target.c vector_table.c zy_if.c
  group STARTUP
    ./Startup/: rt_sys_c.c rt_sys_s.s
  group qrencode
    ./qrencode/: bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group json
    ./json/: cJSON.c jsonmd5.c
  group ssl
    ./ssl/: ssl_tls.c ssl.c md5.c sha1.c
