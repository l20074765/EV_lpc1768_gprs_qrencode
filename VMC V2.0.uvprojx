# Keil uVision project VMC V2.0.uvprojx, settings and files
target VMC-V2.02 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VMC_V2_10_2015_qrencode_V1_0 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Firmware\SRAM_SCT.sct
  link misc: --entry __main
  group APP
    ./APP/: MAIN.C COMMON.C LANGUAGE.C
  group API
    ./API/: qrencodeApi.c
  group DRIVERS
    ./Drivers/: UART2.C UART0.C UART1.C UART3.C RTC.C I2C.C LCD.C KEY.C TIMER.C BUZZER.C AT45DB161D.C GPRS_UART.c
  group uCOS-II
    ./uCOS_II/cpu/: Os_cpu_c.c
    ./uCOS_II/hook/: uCOS-II hook.lib
    ./uCOS_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_TIME.C OS_TASK.C OS_SEM.C OS_Q.C OS_MUTEX.C
  group FIRMWARE
    ./Firmware/: LPC1700PinCfg.c target.c vector_table.c zy_if.c
  group STARTUP
    ./Startup/: rt_sys_c.c rt_sys_s.s
  group qrencode
    ./qrencode/: bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rscode.c split.c
